# Keil uVision project WSN_data_005.uvprojx, settings and files
target RTOS (ARM-ADS)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x00100000) IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WSN_RTOS +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,__CC_ARM
  c include: ..\Code_transplant\Hardware_dwm1000\dwm1000_decadriver;..\Code_transplant\Hardware_dwm1000\dwm1000_port_stm32f405;..\Code_transplant\Library_stm32f405\Cmsis;..\Code_transplant\Library_stm32f405\Driver;..\Code_transplant\Library_stm32f405\Driver\inc;..\Code_transplant\System_freertos\freertos_core;..\Code_transplant\System_freertos\freertos_include;..\Code_transplant\System_freertos\freertos_port_stm32f405;..\Code_user;..\Code_user\Wsn;..\Code_user\malloc;..\Code_user\Peripheral\led;..\Code_user\Peripheral\timer;..\Code_user\Peripheral\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group SYSTEM
    ../Code_user/: head_file.h task_priority_cofig.h main.c
    ../Code_transplant/Library_stm32f405/Driver/: stm32f4xx_it.c
  group WSN
    ../Code_user/Wsn/: coordinatorstates.c wsn_hostcmd.c
  group Protocol
    ../Code_user/Wsn/: usart_protocol.h beacon_protocol.h dataacq_protocol.h
  group Peripheral
    ../Code_user/Peripheral/led/: led.c
    ../Code_user/Peripheral/timer/: delay_tim4.c
    ../Code_user/Peripheral/usart/: usart_coordinator.c
  group RTOS
    ../Code_transplant/System_freertos/freertos_port_stm32f405/: FreeRTOSConfig.h port.c heap_4.c
    ../Code_transplant/System_freertos/freertos_core/: tasks.c queue.c list.c event_groups.c timers.c stream_buffer.c
  group Dwm1000
    ../Code_transplant/Hardware_dwm1000/dwm1000_port_stm32f405/: dwm1000_api.c deca_port_stm32f405.c deca_spi.c deca_sleep.c deca_mutex.c
    ../Code_transplant/Hardware_dwm1000/dwm1000_decadriver/: deca_params_init.c deca_device.c
  group Stm32f405
    ../Code_transplant/Library_stm32f405/Cmsis/: startup_stm32f40_41xxx.s system_stm32f4xx.c stm32f4xx.h
    ../Code_transplant/Library_stm32f405/Driver/: stm32f4xx_conf.h
    ../Code_transplant/Library_stm32f405/Driver/src/: misc.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group Readme
    ../: 0Allocation.txt 0RxM.txt 0program_lib.c 0project_log.c
    ../Code_transplant/System_freertos/: freertos_allocation.txt
    ../Code_transplant/Hardware_dwm1000/: dwm1000_allocation.txt
    ../Code_transplant/Library_stm32f405/: stm32f405_allocation.txt
